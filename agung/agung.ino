/*
LiquidCrystal Library - TextDirection

Demonstrates the use a 16x2 LCD display.  The LiquidCrystal
library works with all LCD displays that are compatible with the
Hitachi HD44780 driver. There are many of them out there, and you
can usually tell them by the 16-pin interface.

This sketch demonstrates how to use leftToRight() and rightToLeft()
to move the cursor.

The circuit:
* LCD RS pin to digital pin 12
* LCD Enable pin to digital pin 11
* LCD D4 pin to digital pin 5
* LCD D5 pin to digital pin 4
* LCD D6 pin to digital pin 3
* LCD D7 pin to digital pin 2
* LCD R/W pin to ground
* 10K resistor:
* ends to +5V and ground
* wiper to LCD VO pin (pin 3)

Library originally added 18 Apr 2008
by David A. Mellis
library modified 5 Jul 2009
by Limor Fried (http://www.ladyada.net)
example added 9 Jul 2009
by Tom Igoe
modified 22 Nov 2010
by Tom Igoe

This example code is in the public domain.

http://www.arduino.cc/en/Tutorial/LiquidCrystalTextDirection

*/

// include the library code:
#include <LiquidCrystal.h>

// initialize the library with the numbers of the interface pins
LiquidCrystal lcd(12, 11, 5, 4, 3, 2);

int thisWord[] = {'A','G','U','N','G',' ','D','W','I',' ','P'} ;
int department[] = {'C','O','M','P','U','T','E','R',' ','S','C','I','E','N','C','E'};

void setup() {
  // set up the LCD's number of columns and rows:
  lcd.begin(16, 2);
  // turn on the cursor:
  lcd.cursor();
}

void loop() {
  /*// reverse directions at 'm':
  if (thisChar == 'm') {
    // go right for the next letter
   lcd.rightToLeft();
  }
  // reverse again at 's':
  if (thisChar == 's') {
    // go left for the next letter
    lcd.leftToRight();
  }
  // reset at 'z':
  if (thisChar > 'z') {
    // go to (0,0):
    lcd.home();
    // start again at 0
    thisChar = 'A';
  }*/
  // print the character
  lcd.setCursor(0,0);
  for(int i=0;i<11;i++){
    lcd.write(thisWord[i]);
    lcd.leftToRight();
    delay(200);
    if(i==10){
      //lcd.clear();
      lcd.home();
    }
  }
  lcd.setCursor(0,1);
  for(int i=0;i<16;i++){
    lcd.write(department[i]);
    lcd.leftToRight();
    delay(200);
    if(i==15){
      lcd.clear();
      lcd.home();
    }
  }
}








